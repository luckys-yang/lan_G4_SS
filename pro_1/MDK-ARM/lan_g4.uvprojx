# Keil uVision project lan_g4.uvprojx, settings and files
target lan_g4 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G431RBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: lan_g4 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G431xx
  c include: ../Core/Inc;                            ../Drivers/STM32G4xx_HAL_Driver/Inc;                            ../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;                            ../Drivers/CMSIS/Device/ST/STM32G4xx/Include;                            ../Drivers/CMSIS/Include;                            ..\APP\LED;                            ..\APP\KEY;                            ..\APP\TIMER;                            ..\APP\KEY_EXTI;                            ..\APP\LCD;                            ..\APP\My_LCD;                            ..\APP;                            ..\APP\USART1;                            ..\APP\My_ADC;                            ..\APP\iic;                            ..\APP\EEPROM;                            ..\APP\PWM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dac.c dma.c rtc.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dac.c stm32g4xx_hal_dac_ex.c stm32g4xx_hal_rtc.c stm32g4xx_hal_rtc_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group APP
    ../APP/LED/: LED.c
    ../APP/KEY/: KEY.c
    ../APP/TIMER/: TIMER.c
    ../APP/KEY_EXTI/: EXTI.c
    ../APP/LCD/: lcd.c
    ../APP/My_LCD/: MY_LCD.c
    ../APP/USART1/: USART1.c
    ../APP/My_ADC/: my_adc.c
    ../APP/iic/: i2c_hal.c
    ../APP/EEPROM/: EEPROM.c
    ../APP/PWM/: PWM.c
software components: CMSIS:CORE 4.3.0
